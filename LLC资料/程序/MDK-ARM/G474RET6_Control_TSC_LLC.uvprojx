# Keil uVision project G474RET6_Control_TSC_LLC.uvprojx, settings and files
target G474RET6_Control_TSC_LLC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: G474RET6_Control_TSC_LLC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32G474xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./User_Code;../../../../My_Library_files/LL_Library/User_Code_Include;../Drivers/CMSIS/DSP/Include;../User_Code_Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c cordic.c dac.c dma.c hrtim.c i2c.c usart.c stm32g4xx_it.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_pwr.c stm32g4xx_ll_comp.c stm32g4xx_ll_rcc.c stm32g4xx_ll_cordic.c stm32g4xx_ll_dac.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group User_Code
    ./User_Code/: Interrupt.c
    ../User_Code_Include/: My_Cordic_LL.c My_Digital_Control_LL.c
  group ARM_MATH
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_q15.c arm_sin_q15.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
